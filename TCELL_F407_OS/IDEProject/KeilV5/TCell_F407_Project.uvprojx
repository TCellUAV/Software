# Keil uVision project TCell_F407_Project.uvprojx, settings and files
target TCell_F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TCell_F407_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\..\StDevice\CORE;..\..\StDevice\DSP_LIB;..\..\StDevice\DSP_LIB\Include;..\..\StDevice\FWLIB\inc;..\..\McuDriver\McuBare_Driver;..\..\Application;..\..\BoardLib\_0_HumanComputerInter;..\..\BoardLib\_1_OhterBase;..\..\BoardLib\_2_EEPROM;..\..\BoardLib\_3_AHRS;..\..\BoardLib\_4_Berometer;..\..\BoardLib\_5_Ultrasonic;..\..\BoardLib\_6_GPS;..\..\BoardLib\_7_OpticalFlow;..\..\BoardLib;..\..\HciCenter;..\..\TCellCore\Core_MathLib;..\..\TCellCore\Core_Attitude;..\..\TCellCore\Core_Calibration;..\..\TCellCore\Core_DataFusion;..\..\TCellCore\Core_Control;..\..\TCellCore\Core_Filter;..\..\TCellCore\Core_Remot;..\..\TCellCore\Core_SafeOperate;..\..\rt-thread-v3.1.0\components\finsh;..\..\rt-thread-v3.1.0\include;..\..\rt-thread-v3.1.0\include\libc;..\..\rt-thread-v3.1.0\add_UserConfig;..\..\rt-thread-v3.1.0\add_SampleAPI\_1_thread;..\..\rt-thread-v3.1.0\add_SampleAPI\_2_idlehook;..\..\rt-thread-v3.1.0\add_SampleAPI\_3_heap;..\..\rt-thread-v3.1.0\add_SampleAPI\_4_semaphore;..\..\rt-thread-v3.1.0\add_SampleAPI\_5_mutex;..\..\rt-thread-v3.1.0\add_SampleAPI\_6_mailbox;..\..\rt-thread-v3.1.0\add_SampleAPI\_7_msgqueue;..\..\rt-thread-v3.1.0\add_SampleAPI\_8_event;..\..\rt-thread-v3.1.0\add_SampleAPI\_9_signal;..\..\rt-thread-v3.1.0\add_SampleAPI\_10_softtimer;..\..\rt-thread-v3.1.0\add_SampleAPI\_11_mempool;..\..\rt-thread-v3.1.0\add_SampleAPI\_12_interrupt;..\..\McuDriver\McuOS_Driver;..\..\rt-thread-v3.1.0\components\drivers\include;..\..\rt-thread-v3.1.0\components\finsh;..\..\rt-thread-v3.1.0\components\libc\compilers\armlibc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ST_Core
    ../../StDevice/CORE/: startup_stm32f407xx.s system_stm32f4xx.c
  group ARM_DSPLib
    ../../StDevice/DSP_LIB/: arm_cortexM4lf_math.lib
  group STM32F4_StdPeriph
    ../../StDevice/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group McuDriver
    ../../McuDriver/McuBare_Driver/: msp_NVIC.c msp_GPIO.c msp_EXTI.c msp_UART.c msp_DMA.c msp_TIM.c msp_I2C.c ssp_SimI2C.c ssp_SimSPI.c
  group Application
    ../../Application/: main.c sys_OsTask.c sys_McuInit.c sys_Debug.c period_Execute.c stm32f4xx_it.c rtos_cpuusage.c sys_Platform.h sys_McuMap.h sys_BoardMap.h sys_ControlMap.h
  group BoardLib
    ../../BoardLib/_0_HumanComputerInter/: bsp_HCI_OLED0_96.c
    ../../BoardLib/_1_OhterBase/: bsp_BASE_Key.c bsp_BASE_LED.c bsp_BASE_RGB.c
    ../../BoardLib/_2_EEPROM/: bsp_EEPROM_AT24CXX.c
    ../../BoardLib/_3_AHRS/: bsp_AHRS_MPU9250.c bsp_IMU_MPU6050.c bsp_MAG_AK8975.c bsp_MAG_HMC5883L.c bsp_MAG_IST8310.c bsp_MAG_HMC5983.c
    ../../BoardLib/_4_Berometer/: bsp_BERO_BMP280.c bsp_BERO_MS5611.c bsp_BERO_SPL06.c
    ../../BoardLib/_5_Ultrasonic/: bsp_ULTR_HCSR04.c bsp_ULTR_RCWL1603.c bsp_ULTR_US100.c
    ../../BoardLib/_6_GPS/: bsp_GPS_M8N.c
    ../../BoardLib/_7_OpticalFlow/: bsp_OPFLOW_UpixelsLC306.c
    ../../BoardLib/: bsp_BoardLib.c
  group HciCenter
    ../../HciCenter/: ANO_DT.c VCAN_DT.c BSK_DT.c Mavlink.c hci_oledshow.c host_Transceive.c hci_show_send_config.h
  group Core_MathLib
    ../../TCellCore/Core_MathLib/: math_Function.c
  group Core_Attitude
    ../../TCellCore/Core_Attitude/: ahrs_Caculation.c attitude_Aircraft.c status_Aircraft.c earth_Declination.c
  group Core_Calibration
    ../../TCellCore/Core_Calibration/: calib_SensorData.c
  group Core_DataFusion
    ../../TCellCore/Core_DataFusion/: sins_Strapdown.c
  group Core_Control
    ../../TCellCore/Core_Control/: pid_System.c adrc_System.c control_Aircraft.c control_AltHold.c control_PosHold.c control_Landing.c control_Mission.c control_Config.h
  group Core_Filter
    ../../TCellCore/Core_Filter/: filter_DataProcess.c filter_Kalman.c
  group Core_Remot
    ../../TCellCore/Core_Remot/: remot_DataAnaly.c
  group Core_SafeOperate
    ../../TCellCore/Core_SafeOperate/: safe_Operation.c
  group OS_UserConfig
    ../../rt-thread-v3.1.0/add_UserConfig/: rtconfig.h board.c
  group OS_Source
    ../../rt-thread-v3.1.0/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group OS_Ports
    ../../rt-thread-v3.1.0/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group OS_SampleAPI
    ../../rt-thread-v3.1.0/add_SampleAPI/_1_thread/: user_thread.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_2_idlehook/: user_idlehook.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_3_heap/: user_heap.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_4_semaphore/: user_semaphore.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_5_mutex/: user_mutex.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_6_mailbox/: user_mailbox.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_7_msgqueue/: user_msgqueue.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_8_event/: user_event.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_9_signal/: user_signal.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_10_softtimer/: user_softtimer.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_11_mempool/: user_mempool.c
    ../../rt-thread-v3.1.0/add_SampleAPI/_12_interrupt/: user_interrupt.c
